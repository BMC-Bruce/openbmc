KBRANCH ?= "dev-5.10"
LINUX_VERSION ?= "5.10.14"

SRCREV="47f127c4370f52bd1edad546a4e29729f20d6d90"

require linux-aspeed.inc
